# Keil uVision project TestLed.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F126 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: TestLed
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: init_uc.c c51F120.h c8051F12.h init_uc.h types.h main.c
